<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32U585_DK_EEPROM.ewp</path>
  </project>
  <batchBuild />
</workspace>
